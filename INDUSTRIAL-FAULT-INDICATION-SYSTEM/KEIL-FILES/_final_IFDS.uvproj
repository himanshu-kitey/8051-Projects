# Keil uVision project _final_IFDS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: _final_IFDS +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: _main_IFDS.c _delay_ms.c _i2c_defines.c _keypad_defines.c _lcd_defines.c _main_defines.c _spi_defines.c _main_IFDS1.c
