# Keil uVision project IFDS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: IFDS
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main_IFDS.c
  group drivers
    ./: dlyMs.c i2cDrivers.c keypadDrivers.c lcdDrivers.c mainDefines.c spiDrivers.c
