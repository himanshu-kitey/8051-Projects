# Keil uVision project I2C_Detect.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: I2C_Detect +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: mainI2CDetect.c lcd_drivers.c dlyMs.c i2cDetectDriver.c lcd_headers.h lcd_defines.h
